# Keil uVision project RobotPcl.uvprojx, settings and files
target RobotPcl (6190000::V6.19::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RobotPcl +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx, __FPU_PRESENT=1U, __FPU_USED=1U
  c include: ../Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../RobotPcl;../platform;../GlobalComponent;..\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c fdcan.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group platform
    ../platform/: platform_init.c platform_can.c
  group platform/arch/stm32
    ../platform/arch/stm32/: can_board.c
  group temp_bsp
    ../bsp/: bsp_dcan.c bsp_flash.c bsp_spi.c bsp_tim2.c bsp_usart_callBack.c bsp_usart1.c bsp_usart2.c bsp_usart3.c bsp_usartQue.c
  group drivers
    ../device/: dv_motor_base.c dv_motor_can.c
  group GlobalComponent
    ../GlobalComponent/: board.c initcall.c pid.c
software components: CMSIS:CORE 5.6.0
