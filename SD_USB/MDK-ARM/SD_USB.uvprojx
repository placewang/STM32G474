# Keil uVision project SD_USB.uvprojx, settings and files
target SD_USB (6190000::V6.19::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SD_USB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../platform;../GlobalComponent;../platform/arch/stm32;../Terminal;..\userDevice;..\Terminal\letter-shell3.x\src;..\Terminal\letter-shell3.x\extensions\log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  link misc: --keep=shellCommand*
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group platform
    ../platform/: platform_init.c platform_uart.c
  group GlobalComponent
    ../GlobalComponent/: board.c initcall.c
  group platform/arch/stm32
    ../platform/arch/stm32/: uart_board.c uart_CallBack.c usartQueue.c
  group testbap
    ../bsp/: bsp_dcan.c bsp_flash.c bsp_spi.c bsp_tim2.c bsp_usart_callBack.c bsp_usart1.c bsp_usart2.c bsp_usart3.c bsp_usartQue.c
  group terminal
    ../Terminal/: shell_port.c
    ../Terminal/letter-shell3.x/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../Terminal/letter-shell3.x/extensions/log/: log.c
  group device
    ../userDevice/: dev_led.c
software components: CMSIS:CORE 5.6.0
